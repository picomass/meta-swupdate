require swupdate.inc

#SRCREV = "47a1246435fdb78fba15cc969596994130412956"

# pointer to picomass fork: 2021.04_socket_patch_dc
SRCREV = "33077be7f08c701d631da84bc1319aa7b089af4c"

LIC_FILES_CHKSUM = "file://LICENSES/GPL-2.0-only.txt;md5=4ee23c52855c222cba72583d301d2338 \
                    file://LICENSES/LGPL-2.1-or-later.txt;md5=4fbd65380cdd255951079008b364516c \
                    file://LICENSES/MIT.txt;md5=838c366f69b72c5df05c96dff79b35f2 \
                    file://LICENSES/BSD-2-Clause.txt;md5=6a31f076f5773aabd8ff86191ad6fdd5 \
                    file://LICENSES/BSD-3-Clause.txt;md5=4a1190eac56a9db675d58ebe86eaf50c"
