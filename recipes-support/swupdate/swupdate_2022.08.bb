require swupdate.inc

#SRCREV = "d542b7fa7c8b7ddb75e7cb3335f5a2590df2edab"

# latest swupdate deklanowski
SRCREV = "d3bab1ebd3c1ab51e740a963489bbe9af26c4474"
